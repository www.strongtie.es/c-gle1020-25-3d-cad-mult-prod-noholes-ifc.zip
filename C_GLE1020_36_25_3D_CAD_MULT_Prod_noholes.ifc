Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-11-09T15:30:08
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Nov 09 15:30:08 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{CB87CA5A-B506-4435-9D35-39A6DB074F8D}\ifc * Database version: 5507 * Database creation date: Thu Nov 09 15:30:08 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Nov 09 15:30:08 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Nov 09 15:30:08 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 4 - 235 Models\Remove Holes\RFA 3D\GLE1020_36_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Graphics - Symbol at End 2 Default: yes; Line Weight: 1; Symbol at End 1 Default: no; Line Pattern: -3000010; Color: 0
Dimensions - Computation Height: 0 mm
Identity Data - Structural: no; Name: Level 1; Building Story: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point

# IfcBuildingElementProxy: GLE1020_36_25, GLE1020_36_25:GLE1020_36_25:177263
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.00821683 ft3
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE1020/36/2.5
General - Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; EPD: https://www.strongtie.eu/eu-EU/EPD; Density: 1.8; Reference: GLE1020/36/2.5; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking
Identity Data - Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Manufacturer: Simpson Strong-Tie; Model ID: 0018727601901072359436782674481097068920; OmniClass Title: Wood Connectors; UniClass Number: Pr_20_29_31_44; URL: www.strongtie.eu; OmniClass Number: 23.20.40.11.24.14; Provide Feedback: mailto:EUdrawings@strongtie.com; Copyright: ©Simpson Strong-Tie; Product Type: Joist hanger; Description: Joist hanger; UniClass Title: Joist hangers; Model: GLE1020/36/2.5; Name: GLE1020/36/2.5; ObjectType: GLE1020/36/2.5
Materials and Finishes - Product Material: Galvanised
